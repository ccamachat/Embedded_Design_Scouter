# Keil uVision project FinalLab.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ./;../
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ../inc/: DAC.c Dump.c LaunchPad.c LED.c PLL.c ST7735.c startup.s Timer0A.c UART.c DAC.h SwitchExternal.h Timer2A.c Timer1A.c Timer1A.h Dump.h Timer3A.c PWM.h PWM.c MQTT.c MQTT.h UART5.h esp8266_base.c esp8266_base.h UART5.c Timer5A.c Timer5A.h I2C2.c I2C2.h I2C0.c I2C0.h Valvano_Unified_Port_Init.c Valvano_Unified_Port_Init.h
  group lib
    ../lib/RGB/: RGB.c
    ../inc/: Switch.h SysTick.h SysTick.c
    ./: Sound.c Sound.h
  group src
    ./: Lab5.c FinalLab.c Unified_Timer_Init.c globalVars.h clock.c clock.h ADC.c ADC.h Lab3_4.c Lab3_4.h Lab4E_Main.c lsm303agr.h LSM303A_driver.c LSM303A_driver.h MAX30102_driver.c MAX30102_driver.h max30102.h Documentation.txt Unified_Port_Init.c Unified_Port_Init.h ESP32-S-CAM_driver.c ESP32-S-CAM_driver.h Buttons.c Buttons.h LSM303AGR_Accelerometer.c LSM303AGR_Accelerometer.h LSM303AGR_Magnetometer.c LSM303AGR_Magnetometer.h Display.c globalFunctions.c globalFunctions.h modes.c modes.h Deprecated_Display.c Deprecated_Display.h
  group tests
    ../tests/: heartbeat_testcases.c esp32-cam_testcases.c imu_testcases.c
    ./: display_test.c
